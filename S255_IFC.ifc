Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-04-25T15:05:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 25 15:05:59 2019 * Host: SarahSams-HP * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{BF1057D9-1812-4AF5-AEA3-732297A5470A}\ifc * Database version: 5507 * Database creation date: Thu Apr 25 15:05:58 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 25 15:05:59 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 25 15:05:59 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Transformer Brushed Stainless Steel, Duten_SoapDpnsrs_S255:Transformer Brushed Stainless Steel:267683
In: Level 0
Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Transformer Polished Stainless Steel; Manufacturer: Duten
Constraints - Level: Level: Level 0; Elevation: 900 mm; Host: Casework_Counter_Top : 625mm_Depth; Default Elevation: 1200 mm
Dimensions - Area: 0.0284195 m2; Volume: 0.000327872 m3
Other - Category: Generic Models; Family: Duten_SoapDpnsrs_S255: Transformer Brushed Stainless Steel; Family and Type: Duten_SoapDpnsrs_S255: Transformer Brushed Stainless Steel; Schedule Level: Level: Level 0; Type: Duten_SoapDpnsrs_S255: Transformer Brushed Stainless Steel; Type Id: Duten_SoapDpnsrs_S255: Transformer Brushed Stainless Steel; AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Moveable; BarCode: n/a; CodePerformance: Pr_40_70_22_81: Soap dispensers; Color: Defined by Finish; Constituents: Stainless Steel Dispenser, Transformer or Battery; DurationUnit: Years; ExpectedLife: 5; Family Name: Duten_SoapDpnsrs_S255; Features: Electronic counter mounted touch-free sensor soap dispenser. Battery or mains powered. Accepts all types of liquid soap, except microbeads. Anti-drip valve distribution system.; Finish: Available in Brushed, Polished or Matte Black Stainless Steel; Grade: n/a; InstallationDate: 1900-12-31T23:59:59; Material: Stainless Steel; ModelNumber: S255-B_SEC; ModelReference: Transformer Polished Stainless Steel; Name: SoapDispensers_S255_Duten; ReplacementCost: 0; SerialNumber: n/a; Shape: Rectangular; Size: (H) 104mm x (L) 108mm x (W) 38mm; SustainabilityPerformance: n/a; TagNumber: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: 5; WarrantyDurationParts: 5; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: contact@duten.fr; WarrantyGuarantorParts: contact@duten.fr; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
General - Author: Diane Butterworth Ltd; ManufacturerName: Duten; ManufacturerURL: http://www.duten.fr/; NBSDescription: Soap dispensers; NBSReference: 45-35-72/358; ProductInformation: https://www.duten.co.uk/products/soap-dispensers/touch-free-soap-dispenser-s255; Revision: n/a; Uniclass2015Code: Pr_40_70_22_81; Uniclass2015Title: Soap dispensers; Uniclass2015Version: Pr-Products v1.10
Identity Data - Assembly Code: E2020200; Assembly Description: Furniture & Accessories; Cost: 0; Description: Transformer Polished Stainless Steel; Keynote: Pr_40_70_22_81; Manufacturer: Duten; Model: S255-B_SEC; Type Comments: Transformer Polished Stainless Steel; Type Name: Transformer Brushed Stainless Steel; URL: http://www.duten.fr/
Materials and Finishes - DispenserFinish: Duten_Metal_BrushedStainlessSteel; SensorFinish: Duten_Plastic_Black

# IfcFurnishingElement: 625mm_Depth, Casework_Counter_Top:625mm_Depth:264176
In: Level 0
Type - ElementType: 625mm_Depth; Material: Laminate - Marble
Type - Dimensions - Counter Thickness: 40 mm; Depth: 625 mm; Height: 900 mm
Type - Graphics - Vis - Worktop Upstand: yes
Type - Identity Data - Keynote: N10; Type Name: 625mm_Depth
Type - Materials and Finishes - Counter Top Material: Laminate - Marble
Type - Other - Category: Casework; Family Name: Casework_Counter_Top
Constraints - Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.895372 m2; Length: 1132.84 mm; Volume: 0.0305137 m3
Other - Family: Casework_Counter_Top: 625mm_Depth; Family and Type: Casework_Counter_Top: 625mm_Depth; Type: Casework_Counter_Top: 625mm_Depth; Type Id: Casework_Counter_Top: 625mm_Depth
Phasing - Phase Created: New Construction
